require mono-4.xx.inc
require ${PN}-base.inc
require mono-${PV}.inc

LIC_FILES_CHKSUM = "file://COPYING.LIB;md5=ae84b2673a35b6ff7fd3507379f9b5e5"
